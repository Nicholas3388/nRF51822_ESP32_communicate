# IAR project gzll_device_ack_payload_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; BSP_DEFINES_ONLY; GAZELL_PRESENT; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\bsp; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\gzll; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10028; BSP_DEFINES_ONLY; GAZELL_PRESENT; NRF51
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\bsp; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\gzll
  OBJCOPY.OOCOutputFile: gzll_device_ack_payload_pca10028.hex
  ILINK.IlinkOutputFile: gzll_device_ack_payload_pca10028.out
  ILINK.IlinkIcfFile: gzll_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main_device_ack_payload.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/iar/: gzll_iar.a
